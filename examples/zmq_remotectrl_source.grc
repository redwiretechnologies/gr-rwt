options:
  parameters:
    generate_options: no_gui
    id: zmq_remotectrl_source
    title: zmq_remotectrl_source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: rwt_source_1
  id: rwt_source
  parameters:
    auto_filter: 'True'
    bandwidth: 15e6
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    escape: '0xAAAAAAAAAAAAAAAA'
    force_reload: 'False'
    freq: 2.4e9
    gain_mode: manual
    manual_gain: '50'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: 10e6
    use_tags: 'True'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://192.168.10.88:5001
    timeout: '100'
  states: {}

connections:
- [rwt_source_1, '0', blocks_tag_debug_0, '0']
- [rwt_source_1, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0, out, rwt_source_1, ctrl]

metadata:
  file_format: 1
