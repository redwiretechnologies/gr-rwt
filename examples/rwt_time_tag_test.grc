options:
  parameters:
    generate_options: no_gui
    id: rwt_time_tag_test
    output_language: python
    title: rwt_time_tag_test
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 16e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nAdds time tags for testing purposes.\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport math\nimport pmt\n\nclass blk(gr.sync_block):\n    \"\"\"Embedded Python Block -- Add Time Tags\"\"\"\n\n    def __init__(self, rate=1e6, period_secs=2.0, samples=500e3):\n        \"\"\"\n        The default arguments set a sampling rate of 1Msps that\n        is on 25% of the time.\n        \"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='RWT Time Tagger',\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n\n        self.period = period_secs\n        self.samples = samples\n        self.rate = rate\n        self.next_tag = 0\n        self.idx = 1\n\n    def work(self, input_items, output_items):\n        \"\"\"Sends time tag every 'period_secs'\"\"\"\n\n        in0 = input_items[0]\n        out0 = output_items[0]\n\n        while (self.nitems_written(0) + len(in0)) > self.next_tag:\n\n            pt_frac, pt_int = math.modf(self.idx * self.period)\n            tag_value = pmt.cons(\n                pmt.from_uint64(int(pt_int)), \n                pmt.from_uint64(int(pt_frac*1e9)))\n\n            self.add_item_tag(\n                0,\n                self.next_tag,\n                pmt.intern(\"tx_time\"),\n                tag_value)\n\n            self.idx += 1\n            self.next_tag += int(self.samples)\n\n        out0[:] = in0\n        return len(out0)\n\n"
    period_secs: '2'
    rate: samp_rate
    samples: samp_rate/2
  states: {}
- name: sink
  id: rwt_sink
  parameters:
    attenuation1: '50'
    attenuation2: '50'
    auto_filter: 'True'
    bandwidth: bw
    base_addr: '0x9D000000'
    buffer_size: '32000'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: sample_idx_now=0
    filter: ''
    force_reload: 'False'
    freq: 2.398e9
    rfport: A
    samplerate: samp_rate
    tx1_en: 'True'
    tx2_en: 'False'
    use_tags: 'True'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', epy_block_0, '0']
- [epy_block_0, '0', sink, '0']

metadata:
  file_format: 1
