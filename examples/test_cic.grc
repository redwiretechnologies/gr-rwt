options:
  parameters:
    generate_options: qt_gui
    id: defaultid
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '4'
    type: short
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_probe_rate_0_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: short
  states: {state: disabled}
- name: rwt_source_0
  id: rwt_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(40e6)
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    bypass_enable: '0'
    correction_enable: 'True'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    filter: ''
    force_reload: 'False'
    freq: 2.4e9
    gain_mode: manual
    manual_gain: '64.0'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    use_tags: 'True'
  states: {}
- name: rwt_source_s16_0
  id: rwt_source_s16
  parameters:
    auto_filter: 'True'
    bandwidth: int(40e6)
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    bypass_enable: 'False'
    correction_enable: 'True'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    filter: ''
    force_reload: 'False'
    freq: 2.4e9
    gain_mode: manual
    manual_gain: '64.0'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    use_tags: 'True'
  states: {state: disabled}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_probe_rate_0_0, rate, blocks_message_debug_0, print]
- [rwt_source_0, '0', blocks_null_sink_1, '0']
- [rwt_source_0, '1', blocks_null_sink_1, '1']
- [rwt_source_0, '1', blocks_probe_rate_0, '0']
- [rwt_source_s16_0, '0', blocks_null_sink_0, '1']
- [rwt_source_s16_0, '1', blocks_null_sink_0, '0']
- [rwt_source_s16_0, '2', blocks_null_sink_0, '2']
- [rwt_source_s16_0, '3', blocks_null_sink_0, '3']
- [rwt_source_s16_0, '3', blocks_probe_rate_0_0, '0']

metadata:
  file_format: 1
