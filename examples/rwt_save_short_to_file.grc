options:
  parameters:
    generate_options: no_gui
    id: rwt_save_short_to_file
    output_language: python
    title: RWT Save to File
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: real_filename
    type: short
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: short_filename
    type: short
  states: {}
- name: rwt_source_s16_0
  id: rwt_source_s16
  parameters:
    auto_filter: 'True'
    bandwidth: 40e6
    base_addr: '0x9D000000'
    bbdc: 'True'
    buffer_size: '32000'
    escape: '0xAAAAAAAAAAAAAAAA'
    extra: ''
    filter: ''
    force_reload: 'False'
    freq: 2.4e9
    gain_mode: manual
    manual_gain: '64.0'
    quadrature: 'True'
    rfdc: 'True'
    rfport1: A_BALANCED
    rfport2: A_BALANCED
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: 1e6
    use_tags: 'True'
  states: {}
- name: real_filename
  id: parameter
  parameters:
    type: str
    value: /tmp/real.bin
  states: {}
- name: short_filename
  id: parameter
  parameters:
    type: str
    value: /tmp/imag.bin
  states: {}

connections:
- [rwt_source_s16_0, '0', blocks_file_sink_0, '0']
- [rwt_source_s16_0, '1', blocks_file_sink_0_0, '0']

metadata:
  file_format: 1
